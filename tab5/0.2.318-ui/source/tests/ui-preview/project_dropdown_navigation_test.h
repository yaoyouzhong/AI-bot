static void check_project_dropdown_navigation(void) {
 const char *fixture="{\"epochMilliseconds\":1793758000000,\"pcInput\":{\"session\":\"dropdown-fixture\"},\"codexTasks\":{\"projects\":[{\"id\":\"1111111111111111\",\"name\":\"Codex A\"},{\"id\":\"4444444444444444\",\"name\":\"Codex B\"}],\"tasks\":[{\"id\":\"11111111-1111-4111-8111-111111111111\",\"projectId\":\"1111111111111111\",\"title\":\"Codex navigation\"}]},\"claudeTasks\":{\"projects\":[{\"id\":\"2222222222222222\",\"name\":\"Claude A\"},{\"id\":\"5555555555555555\",\"name\":\"Claude B\"}],\"tasks\":[{\"id\":\"22222222-2222-4222-8222-222222222222\",\"projectId\":\"2222222222222222\",\"title\":\"Claude navigation\"}]}}";
 cJSON_Delete(shown);shown=cJSON_Parse(fixture);assert(shown);
 cJSON_ReplaceItemInObject(cJSON_GetArrayItem(item(item(shown,"codexTasks"),"projects"),0),"name",cJSON_CreateString("claude-voice-test-project-with-long-name"));
 cJSON_ReplaceItemInObject(cJSON_GetArrayItem(item(item(shown,"claudeTasks"),"projects"),0),"name",cJSON_CreateString("这是一个用于检查项目选择框的很长中文项目名称"));
 for(unsigned client=0;client<2;client++) {
  workspace_client=client;codex_selected[0]=0;codex_project_selected[0]=0;
  codex_default_pending=codex_default_all=true;page(8);render_codex();
  lv_obj_update_layout(lv_screen_active());
  lv_area_t caption_area,picker_area;lv_obj_get_coords(codex_project_caption,&caption_area);lv_obj_get_coords(codex_project_picker,&picker_area);
  lv_point_t arrow;lv_text_get_size(&arrow,LV_SYMBOL_DOWN,lv_obj_get_style_text_font(codex_project_picker,LV_PART_INDICATOR),0,0,LV_COORD_MAX,LV_TEXT_FLAG_NONE);
  assert(caption_area.x2+12<=picker_area.x2-lv_obj_get_style_pad_right(codex_project_picker,0)-arrow.x+1);
  assert(!lv_obj_has_flag(codex_project_caption,LV_OBJ_FLAG_CLICKABLE));
  assert(strstr(lv_dropdown_get_options(codex_project_picker),client?"这是一个用于检查项目选择框的很长中文项目名称":"claude-voice-test-project-with-long-name"));
  assert(lv_label_get_text(codex_project_caption)[0]);
  assert(lv_label_get_long_mode(codex_project_caption)==LV_LABEL_LONG_DOT);
  assert(lv_color_eq(lv_obj_get_style_bg_color(codex_camera_button,0),lv_obj_get_style_bg_color(codex_voice_button,0)));
  assert(lv_obj_get_style_radius(codex_camera_button,0)==lv_obj_get_style_radius(codex_voice_button,0));
  lv_area_t camera_area,mic_area,send_area,input_area;
  lv_obj_get_coords(codex_camera_button,&camera_area);lv_obj_get_coords(codex_voice_button,&mic_area);
  lv_obj_get_coords(codex_send_button,&send_area);lv_obj_get_coords(codex_input,&input_area);
  assert(camera_area.x1>=input_area.x1+350&&mic_area.x1-camera_area.x2>=25);
  assert(send_area.x1-mic_area.x2>=41&&send_area.x2==input_area.x2);
  assert(camera_area.y1==mic_area.y1&&mic_area.y1==send_area.y1&&mic_area.y2==send_area.y2);
  assert(lv_obj_get_x(codex_camera_button)+36==414&&lv_obj_get_x(codex_voice_button)+36==518);
  assert(lv_obj_get_style_radius(codex_send_button,0)==36&&lv_obj_get_style_radius(codex_voice_cancel,0)==36);
  assert(lv_obj_get_width(codex_camera_button)==72&&lv_obj_get_height(codex_camera_button)==72);
  assert(lv_obj_get_width(codex_voice_button)==72&&lv_obj_get_height(codex_voice_button)==72);
  char selected[37],project[17];snprintf(selected,sizeof(selected),"%s",codex_selected);snprintf(project,sizeof(project),"%s",codex_project_selected);
  assert(selected[0]&&project[0]);
  codex_set_text(client?"Claude retained draft":"Codex retained draft");
  codex_draft *draft=codex_draft_for(selected,true);assert(draft);
  assert(codex_store_text(draft,lv_textarea_get_text(codex_input),false));draft->loaded=true;draft->dirty=false;
  lv_dropdown_open(codex_project_picker);assert(lv_dropdown_is_open(codex_project_picker));
  capture(client?"dropdown-claude-open":"dropdown-codex-open");
  page(0);
  capture(client?"dropdown-claude-overview":"dropdown-codex-overview");
  assert(!lv_dropdown_is_open(codex_project_picker));
  assert(!strcmp(selected,codex_selected)&&!strcmp(project,codex_project_selected));
  page(8);assert(!lv_dropdown_is_open(codex_project_picker));
  assert(!strcmp(lv_textarea_get_text(codex_input),client?"Claude retained draft":"Codex retained draft"));
  capture(client?"dropdown-claude-return":"dropdown-codex-return");
  ui_text(codex_physical,"键盘已连接");lv_obj_update_layout(lv_screen_active());
  lv_area_t physical_area,hint_area,switch_area,cancel_area;
  lv_obj_get_coords(codex_physical,&physical_area);lv_obj_get_coords(codex_voice_hint,&hint_area);
  lv_obj_get_coords(codex_voice_switch,&switch_area);lv_obj_get_coords(codex_voice_cancel,&cancel_area);
  assert(physical_area.x2+16<switch_area.x1&&switch_area.x2+16<camera_area.x1);
  assert(hint_area.y1>mic_area.y2&&lv_obj_get_height(codex_voice_hint)>=64);
  assert(cancel_area.x1==send_area.x1&&hint_area.y1>cancel_area.y2);
  capture(client?"dialogue-claude-keyboard":"dialogue-codex-keyboard");
  lv_obj_add_state(codex_camera_button,LV_STATE_PRESSED);lv_obj_add_state(codex_voice_button,LV_STATE_PRESSED);
  assert(lv_color_eq(lv_obj_get_style_bg_color(codex_camera_button,0),lv_obj_get_style_bg_color(codex_voice_button,0)));
  capture(client?"dialogue-claude-pressed":"dialogue-codex-pressed");
  lv_obj_remove_state(codex_camera_button,LV_STATE_PRESSED);lv_obj_remove_state(codex_voice_button,LV_STATE_PRESSED);
  memset(&preview_voice,0,sizeof(preview_voice));snprintf(preview_voice.task_id,sizeof(preview_voice.task_id),"%s",selected);
  preview_voice.busy=true;strcpy(preview_voice.phase,"preparing");
  codex_voice_waiting=true;codex_voice_desktop=false;ui_text(codex_receipt,"上一条操作提示");codex_voice_tick();
  assert(!lv_label_get_text(codex_receipt)[0]);
  assert(!lv_obj_has_flag(codex_camera_button,LV_OBJ_FLAG_HIDDEN)&&lv_obj_has_state(codex_camera_button,LV_STATE_DISABLED));
  capture(client?"dialogue-claude-preparing":"dialogue-codex-preparing");
  preview_voice.busy=preview_voice.ready=true;strcpy(preview_voice.phase,"recording");strcpy(preview_voice.source,"dji");
  codex_voice_waiting=true;codex_voice_desktop=false;codex_voice_tick();
  assert(lv_color_eq(lv_obj_get_style_bg_color(codex_voice_button,0),lv_color_hex(0x365D48)));
  assert(!lv_obj_has_flag(codex_stop_glyph,LV_OBJ_FLAG_HIDDEN));
  assert(!lv_obj_has_flag(codex_camera_button,LV_OBJ_FLAG_HIDDEN)&&lv_obj_has_state(codex_camera_button,LV_STATE_DISABLED));
  capture(client?"dialogue-claude-recording":"dialogue-codex-recording");
  unsigned commands_before=preview_voice_commands;lv_obj_send_event(codex_voice_switch,LV_EVENT_CLICKED,NULL);
  assert(preview_voice_commands==commands_before+1&&preview_voice_command==3);
  preview_voice.ready=false;strcpy(preview_voice.source,"tab5");strcpy(preview_voice.phase,"preparing");codex_voice_tick();
  capture(client?"dialogue-claude-switching":"dialogue-codex-switching");
  preview_voice.ready=true;strcpy(preview_voice.phase,"recording");codex_voice_tick();
  assert(lv_obj_has_flag(codex_voice_switch,LV_OBJ_FLAG_HIDDEN));
  capture(client?"dialogue-claude-tab5-recording":"dialogue-codex-tab5-recording");
  preview_voice.ready=false;strcpy(preview_voice.phase,"recognizing");codex_voice_tick();
  assert(!lv_obj_has_flag(codex_camera_button,LV_OBJ_FLAG_HIDDEN)&&lv_obj_has_state(codex_camera_button,LV_STATE_DISABLED));
  capture(client?"dialogue-claude-recognizing":"dialogue-codex-recognizing");
  preview_voice.busy=false;strcpy(preview_voice.phase,"error");strcpy(preview_voice.message,"语音连接已中断，请检查电脑上的语音服务后重试。");codex_voice_tick();
  capture(client?"dialogue-claude-error":"dialogue-codex-error");
  codex_voice_waiting=true;
  preview_voice.busy=false;strcpy(preview_voice.phase,"review");codex_voice_tick();
  ui_text(codex_physical,"");
  assert(lv_color_eq(lv_obj_get_style_bg_color(codex_camera_button,0),lv_obj_get_style_bg_color(codex_voice_button,0)));
  assert(!lv_obj_has_state(codex_camera_button,LV_STATE_DISABLED));
  for(int i=0;i<3;i++) {
   assert(!draft->images[i][0]&&!draft->thumbnails[i]);
   snprintf(draft->images[i],sizeof(draft->images[i]),"33333333-3333-4333-8333-%012d",i);
   draft->thumbnails[i]=calloc(96*54,sizeof(uint16_t));assert(draft->thumbnails[i]);
   for(int y=0;y<54;y++)for(int x=0;x<96;x++)draft->thumbnails[i][y*96+x]=(x>28&&x<71&&y>5&&y<49)?((y==20||y==28||y==36)&&x>35&&x<63?0x8410:0xDEDA):0x4AEB;
  }
  codex_set_text("请查看照片，帮我整理一下。");codex_images_refresh();lv_obj_update_layout(lv_screen_active());
  for(int i=0;i<3;i++){lv_area_t a;lv_obj_get_coords(composer_photos[i],&a);assert(a.y2+12<=camera_area.y1);}
  ui_text(codex_receipt,"已添加 3/3 张");capture(client?"dialogue-claude-three-photos":"dialogue-codex-three-photos");
  for(int i=0;i<3;i++){draft->images[i][0]=0;free(draft->thumbnails[i]);draft->thumbnails[i]=NULL;}
  codex_images_refresh();
  lv_dropdown_open(codex_project_picker);assert(lv_dropdown_is_open(codex_project_picker));
  page_select(0,false);assert(!lv_dropdown_is_open(codex_project_picker));
 }
 puts("PROJECT_DROPDOWN_NAVIGATION_OK both_clients immediate_close overview return project_and_draft_retained common_tab_navigation_path");
}
